options:
  parameters:
    author: anunn
    generate_options: qt_gui
    id: Savedata
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: D:\Passive-Radar\Autocorr_Signal Generator.dat
    type: complex
  states: {}
- name: soapy_rtlsdr_source_0
  id: soapy_rtlsdr_source
  parameters:
    center_freq: '100000000'
    gain: '30'
    samp_rate: '2400000'
    type: fc32
  states: {}

connections:
- [soapy_rtlsdr_source_0, '0', blocks_file_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
